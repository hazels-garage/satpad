File: pcbs/satpad.kicad_pcb (KiCad board)
At the start: 2 copper layers, 202.5 x 51 mm, 65 parts

Commit message: cleanup and gerbers
Parts:
- removed the G*** at (94.0, -20.4)
